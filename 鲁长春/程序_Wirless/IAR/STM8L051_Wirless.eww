<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8L051_Wirless.ewp</path>
  </project>
  <batchBuild/>
</workspace>


