# IAR project STM8L051lowpower.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\HARD; ..\lib; ..\usr; ..\iar; ..\MYFUN
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: wirless_01.hex
  ILINK.IlinkOutputFile: STM8L051lowpower.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group HARD
    ../HARD/: ADC_CHECK.C BAT.C KEYBOARD.C stmflash.c
  group LIB
    ../LIB/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim3.c stm8l15x_usart.c
  group library
    ../HARD/: 24l01.c NRF24L01_AUTO_ACK.c PWM.C
  group MAIN
    ../USR/: main.c stm8l15x_it.c UHEAD.C
  group MYFUN
    ../MYFUN/: MyCLK.c
