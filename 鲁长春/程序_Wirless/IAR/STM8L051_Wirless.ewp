# IAR project STM8L051_Wirless.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\HARD; ..\lib; ..\usr; ..\iar; ..\MYFUN
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 遥控7.1-改版DM，修复BUG.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\library\libcui.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group DATA
    ../USR/: UDATA.H uhead.h
  group HARD
    ../HARD/: KEYBOARD.C MYCLK.C stmflash.c
  group LIB
    ../LIB/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_usart.c
  group lib
    ../../../新建文件夹/wirless/: 24l01.c NRF24L01_AUTO_ACK.c
  group MAIN
    ../USR/: main.c UHEAD.C
