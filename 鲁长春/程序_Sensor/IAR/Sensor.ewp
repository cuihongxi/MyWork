# IAR project Sensor.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\HARD; ..\lib; ..\usr; ..\iar; ..\MYFUN
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 传感器-2.24-上电LED指示晴天只发一次.hex
  ILINK.IlinkOutputFile: STM8L051lowpower.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\library\libcui.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group DATA
    ../USR/: UDATA.H UHEAD.H
  group HARD
    ../HARD/: ADC_CHECK.C BAT.C FL.C LED_SHOW.C MYCLK.C stmflash.c
  group LIB
    ../LIB/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_usart.c stm8l15x_wwdg.c
  group MAIN
    ../USR/: main.c stm8l15x_it.c UHEAD.C
