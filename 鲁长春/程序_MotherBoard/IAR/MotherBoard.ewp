# IAR project MotherBoard.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\LIB; ..\HARD; ..\USR; ..\LIB\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 14.2.hex
  ILINK.IlinkOutputFile: MotherBoard.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: ..\library\libcui.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group DATA
    ../USR/: UDATA.H uhead.h
  group HARD
    ../HARD/: ADC_CHECK.C BAT.C FL.C KEYBOARD.C LED_SHOW.C MX830Motor.C MYCLK.C NRF_App.c stmflash.c
  group LIB
    ../LIB/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_usart.c stm8l15x_wwdg.c
  group lib
    ../../../新建文件夹/: 24l01.c CUI_MALLOC0.C CUI_MALLOC1.C CUI_RTOS.C NRF24L01_AUTO_ACK.c SingleCycList.c SingleList.c
  group main
    ../USR/: main.c stm8l15x_it.c UHEAD.C
  group README
    ../: README.txt
